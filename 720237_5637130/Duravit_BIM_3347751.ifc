Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Showers_DURAVIT-AG_Starck-Slimline-Shower-tray-1500x800-mm.ifc
Time: 2023-02-28T10:51:46
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Starck Slimline Shower tray 1500x800 mm - 720237
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Starck Slimline Shower tray 1500x800 mm - 720237; SKU (BO_prodsku): Starck-Slimline-Shower-tray-1500x800-mm-720237; ManufacturName (BO_Manufac): DURAVIT AG; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): Starck Slimline; ProductGroup (BO_prodgroup): Shower tray; DesignCountry (BO_designcont): Germany; EditionNumber (BO_edinum): 1; Width (BO_width): 1500; Height (BO_height): 60; Depth (BO_depth): 800; Weight (BO_weight): 23; QR (BO_boqrurl): http://bimobject.com/duravit/product/Starck-Slimline-Shower-tray-1500x800-mm-720237; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/Starck-Slimline-Shower-tray-1500x800-mm-720237; ProductUrl (BO_producturl): http://pro.duravit.com/p/720237; InstallationInstructions (BO_montins): http://pro.duravit.com/p/720237; ProductCertification (BO_prodcert): http://pro.duravit.com/p/720237; TechnicalDescription (BO_techcert): http://pro.duravit.com/p/720237; InstructionVideo (BO_youtube): http://pro.duravit.com/p/720237; MaterialMain (BO_mainmat): Acrylic; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Showers; BimObjectCategoryCode (BO_bocat_code): showers; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspscCode (BO_unspsc): 30181503; Uniclass2015Code (BO_uniclass2015_code): SL_35_80_80; Uniclass2015Description (BO_uniclass2015_desc): Showers; OmniClassCode (BO_omniclass_code): 23-31 17 00; OmniClassDescription (BO_omniclass_name): Showers; MasterFormat2014Code (BO_masterformat2014_code): 22 41 23; MasterFormat2014Description (BO_masterformat2014_name): Residential Showers; UniFormat2Code (BO_uniformat2_code): D2010; UniFormat2Description (BO_uniformat2_name): Plumbing Fixtures; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
